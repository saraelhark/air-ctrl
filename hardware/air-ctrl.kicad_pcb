# Repository saraelhark/air-ctrl

File README.md:

# air-ctrl

Air quality wrist band

## Features

- air quality monitoring (humidity, VOC, temperature, pressure)
- wearable/portable
- bluetooth
- display
- rechargeable via USB C

## Major Components

[datasheets](docs/datasheets.md)

## Constraints

- size: 35x35mm
- low power consumption

## Firmware

To setup, build and flash the firmware, see [firmware/README.md](firmware/README.md)

## KiCad design hardware/air-ctrl.kicad_pcb

Parts:
AE1: Antenna_BLE
C11, C23: 100nF; C_0603_1608Metric
C12: 100pF; C_0603_1608Metric
C13, C14, C15, C16: 12pF; C_0603_1608Metric
C17: 1.5pF; C_0201_0603Metric
C18: 1uF; C_0603_1608Metric
C20, C21: 0.1uF; C_0603_1608Metric
C22: 4.7uF; C_0603_1608Metric
C25: 0.8pF; C_0201_0603Metric
C26: NC; C_0201_0603Metric
J3: Conn_ARM_SWD_TagConnect_TC2030-NL; Tag-Connect_TC2030-IDC-NL_2x03_P1.27mm_Vertical
L1: 3.9nH; L_0201_0603Metric
L2: 10uH; L_0603_1608Metric
L3: 15uH; L_0603_1608Metric
R16: 0R; R_0201_0603Metric
R17: 10k; R_0603_1608Metric
SW1: SW_RST; SW_SPST_B3U-1000P
TP7: TP_SCL; TestPoint_Pad_D1.0mm
TP8: TP_SDA; TestPoint_Pad_D1.0mm
U1: nRF52832-QFxx; QFN-48-1EP_6x6mm_P0.4mm_EP4.6x4.6mm
Y1: 32MHz; Crystal_SMD_2016-4Pin_2.0x1.6mm
Y2: 32.768kHz; Crystal_SMD_3215-2Pin_3.2x1.5mm

Connections:
-BATT: C11.2, C12.2, C13.1, C14.1, C15.2, C16.2, C17.2, C18.2, C20.2, C21.2, C22.2, C23.1, C25.2, C26.2, J3.5 (GND), SW1.1, U1.31 (VSS), U1.45 (VSS), U1.49 (VSS), Y1.2, Y1.4; also elsewhere on the board
/display/DISP_BL: U1.12 (NFC2/P0.10); also elsewhere on the board
/display/DISP_CS: U1.15 (P0.12); also elsewhere on the board
/display/DISP_DC: U1.18 (P0.15); also elsewhere on the board
/display/DISP_MOSI: U1.17 (P0.14); also elsewhere on the board
/display/DISP_RST: U1.14 (P0.11); also elsewhere on the board
/display/DISP_SCLK: U1.16 (P0.13); also elsewhere on the board
/mcu/I2C_SCL: TP7.1, U1.38 (P0.26); also elsewhere on the board
/mcu/I2C_SDA: TP8.1, U1.39 (P0.27); also elsewhere on the board
/power/V_3V3: C20.1, C21.1, C22.1, J3.1 (VCC), R17.2, U1.13 (VDD), U1.36 (VDD), U1.48 (VDD); also elsewhere on the board
unnamed: AE1.1 (FEED), C17.1, R16.1
unnamed: C26.1, L1.1, R16.2
unnamed: J3.4 (SWCLK), U1.25 (SWDCLK)
unnamed: J3.2 (SWDIO), U1.26 (SWDIO)
unnamed: J3.6 (SWO), U1.21 (P0.18/SWO)
unnamed: C23.2, J3.3 (~RESET), R17.1, SW1.2, U1.24 (P0.21/~RESET)
unnamed: L2.1, L3.2
unnamed: C25.1, L1.2, U1.30 (ANT)
unnamed: L2.2, U1.47 (DCC)
unnamed: C11.1, U1.1 (DEC1)
unnamed: C12.1, U1.33 (DEC3)
unnamed: C18.1, L3.1, U1.46 (DEC4)
unnamed: C15.1, U1.2 (P0.00/XL1), Y2.1
unnamed: C16.1, U1.3 (P0.01/XL2), Y2.2
unnamed: C13.2, U1.34 (XC1), Y1.1
unnamed: C14.2, U1.35 (XC2), Y1.3

Parts:
C6: 10uF; C_0603_1608Metric
C7: 100uF; C_0603_1608Metric
C8, C9: 1uF; C_0603_1608Metric
C24: 100nF; C_0603_1608Metric
D1: CHG_LED; LED_0805_2012Metric
D2: PWR_LED; LED_0805_2012Metric
D3: LBAT_LED; LED_0805_2012Metric
D4: ESD5Zxx; D_SOD-523
F1: Polyfuse; Fuse_1206_3216Metric
J1: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_GCT_USB4110
J4: Conn_01x02; JST_PH_S2B-PH-SM4-TB_1x02-1MP_P2.00mm_Horizontal
R8, R9: 5.1k; R_0603_1608Metric
R10, R11, R12: 10k; R_0603_1608Metric
R13, R14, R15: 12k; R_0603_1608Metric
TP1: TP_VBATT; TestPoint_Pad_D1.0mm
TP2: TP_VIN; TestPoint_Pad_D1.0mm
TP3: TP_VOUT; TestPoint_Pad_D1.0mm
TP4: TP_3V3; TestPoint_Pad_D1.0mm
TP5, TP9: TP_GND; TestPoint_Pad_D1.0mm
TP6: TP_VBUS; TestPoint_Pad_D1.0mm
U3: MCP73871-2CC; QFN-20-1EP_4x4mm_P0.5mm_EP2.5x2.5mm
U4: MCP1700x-330xxTT; SOT-23

Connections:
+BATT: C7.1, J4.1, TP1.1, U3.14 (V_{BAT}), U3.15 (V_{BAT}), U3.16 (V_{BAT_SENSE})
-BATT: C6.2, C7.2, C8.2, C9.2, C24.2, D4.2 (A), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J4.2, R8.2, R9.2, R10.2, R11.2, R12.2, TP5.1, TP9.1, U3.3 (SEL), U3.4 (PROG2), U3.9 (~TE), U3.10 (V_{SS}), U3.11 (V_{SS}), U3.21 (V_{SS}), U4.1 (GND); also elsewhere on the board
/power/V_3V3: C9.1, D1.2 (A), D2.2 (A), D3.2 (A), TP4.1, U4.2 (VO); also elsewhere on the board
/power/V_BUS: C24.1, D4.1 (K), F1.1, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), TP6.1
/power/V_IN: C6.1, F1.2, TP2.1, U3.2 (VPCC), U3.17 (CE), U3.18 (IN), U3.19 (IN)
unnamed: D1.1 (K), R13.1
unnamed: D2.1 (K), R14.1
unnamed: D3.1 (K), R15.1
unnamed: J1.A5 (CC1), R8.1
unnamed: J1.B5 (CC2), R9.1
unnamed: R10.1, U3.13 (PROG1)
unnamed: R12.1, U3.12 (PROG3)
unnamed: R15.2, U3.8 (STAT1/~LBO)
unnamed: R13.2, U3.7 (STAT2)
unnamed: R11.1, U3.5 (THERM)
unnamed: R14.2, U3.6 (~PG)
unnamed: C8.1, TP3.1, U3.1 (OUT), U3.20 (OUT), U4.3 (VI)

Notes on the sheet:
Battery connector
PG - Input power present STAT1 - Low battery indicator STAT2 - Charging indicator
100mA charge current
ESD protection

Parts:
C1, C2: 10uF; C_0603_1608Metric
C3: 0.1uF; C_0603_1608Metric
J2: SFV24R-2STE1HLF; AMPHENOL_SFV24R-2STE1HLF; PARTREV C
Q1: BSS138; SOT-23
R1, R2, R5: 10k; R_0603_1608Metric

Connections:
-BATT: C1.2, C2.2, C3.2, J2.3 (GND), J2.11 (RD), J2.13 (DB0), J2.14 (DB1), J2.15 (DB2), J2.16 (DB3), J2.17 (DB4), J2.18 (DB5), J2.19 (DB6), J2.20 (DB7), J2.23 (GND), J2.24 (GND), J2.S1 (SHIELD), J2.S2 (SHIELD__1), Q1.2 (S); also elsewhere on the board
/display/DISP_BL: Q1.1 (G), R5.2; also elsewhere on the board
/display/DISP_CS: J2.8 (CS), R2.2; also elsewhere on the board
/display/DISP_DC: J2.10 (WR); also elsewhere on the board
/display/DISP_MOSI: J2.12 (SDA); also elsewhere on the board
/display/DISP_RST: J2.7 (RESET), R1.2; also elsewhere on the board
/display/DISP_SCLK: J2.9 (DC); also elsewhere on the board
/display/LEDK: J2.2 (LEDK), Q1.3 (D)
/power/V_3V3: C1.1, C2.1, C3.1, J2.1 (LEDA), J2.4 (VDD2.8V), J2.5 (IOVCC1.8V), J2.6 (IM1/2), R1.1, R2.1, R5.1; also elsewhere on the board

Notes on the sheet:
to disable display during MCU reset
decoupling capacitors to protect the IC from voltage fluctuations and noise on power line
Switch to PWM the backlight
To select 4-SPI (1 bit) - pull high

Parts:
C4: 0.1uF; C_0603_1608Metric
C5: 4.7uF; C_0603_1608Metric
R6, R7: 4.7k; R_0603_1608Metric
U2: BME688; IC_BME688; PARTREV 1.0

Connections:
-BATT: C4.2, C5.2, U2.1 (GND), U2.5 (SDO), U2.7 (GND__1); also elsewhere on the board
/mcu/I2C_SCL: R7.2, U2.4 (SCK); also elsewhere on the board
/mcu/I2C_SDA: R6.2, U2.3 (SDI); also elsewhere on the board
/power/V_3V3: C4.1, C5.1, R6.1, R7.1, U2.2 (CSB), U2.6 (VDDIO), U2.8 (VDD); also elsewhere on the board

Board: 2 copper layers, 35.0 x 35.0 mm, 69 parts (27 on the bottom side), 42 nets.

## Commit log

2025-10-04 Selected a few components and structured the repo
2025-10-04 wip schematic
    hierarchy and importing components
2025-10-05 fixed display schematic
2025-10-06 implemented sensor circuit
2025-10-06 wip: power circuit
2025-10-07 finished first draft of schematic, need to review
2025-10-08 fixed schematic
2025-10-11 changed to smd components, wip layout
2025-10-11 wip: layout on the back side
2025-10-11 connected power and signals, gnd missing
2025-10-12 wip layout
2025-10-12 fixed connections to ground and DRC
2025-10-12 fixed references placements
2025-10-13 bug fix: debounce capacitor for reset button
2025-10-13 change to 2-pin ESD protection diode
2025-10-15 fixed antenna layout
    wip: placing components
2025-10-17 Fixed layout bottom layer
    Also fixed all DRC issues
2025-10-18 routing power lines, fixing schematic
    using 3.3V to power LEDs, fixed CE-pin to be low
2025-10-18 improved layout to shorten 3.3V power traces
2025-10-18 Added name and revision
2025-10-18 Fixed DRC issues on antenna pad and trace
2025-10-18 Fixed some R and C values, added missing 3D models
2025-10-18 fixed exposed antenna pad, now it's a track
2025-10-18 Added ground pour on top and bottom layers, added via stitching
2025-10-18 Adjusted PCB stack to match the nRF usb dongle used for ref
    Mostly for the antenna design
2025-10-18 removed vias in pads, simplified a few things
2025-10-19 fixed small things before final review
2025-10-19 Exclude Test points and such from BOM
2025-10-19 init sample zephyr project
2025-10-19 configured peripherals and pins in device tree
2025-10-22 Fixes after nordic review
    ready to order!
2025-10-22 fixed release fields
2025-11-04 flashing both DK and my custom board works!
2025-11-07 fixed board conf to try i2c sensor (working!)
2025-11-09 basic bluetooth works!
    need to doublecheck the storage and settings config if necessary
2025-11-10 wip testing spi and display, not working
2025-11-12 wip: testing display
2025-11-13 still nothing on display..
2025-11-13 still no luck with display, will skip for now
2025-12-11 disabled/removed spi and display stuff
2025-12-12 added external library (cannot commit)
2025-12-13 Integrated the bsec library as optional
    Default is raw sensor readings via the zephyr driver
2025-12-14 added store and load of configuration
    quicker stabilization after restarts
2025-12-14 fixed RTT logging and added utility script to plot data live
2025-12-14 implemented simple bluetooth broadcasting
    tested with nRF connect ios app
